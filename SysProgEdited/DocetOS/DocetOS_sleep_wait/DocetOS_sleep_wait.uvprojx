# Keil uVision project DocetOS_sleep_wait.uvprojx, settings and files
target STM32F303 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DocetOS_sleep_wait
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xx,STM32F3XX
  c misc: --c99
  c include: .\OS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System_F303
    ./utils/: config_f303.c retarget_f303.c
  group System_F407
    ./utils/: config_f407.c retarget_f407.c
  group Source Files
    ./: main.c simpleRoundRobin.c
  group OS
    ./OS/: os_asm.s os.c
    ./: sleep.c sleep.h mutex.h mutex.c semaphore.h semaphore.c mempool.h mempool.c circbuffer.h circbuffer.c fixedPriority.h fixedPriority.c
  group Debug
    ./utils/: hardfault.c
target STM32F407 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DocetOS_sleep_wait
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,STM32F4XX,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  c misc: --c99
  c include: .\OS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:Startup 2.6.3
